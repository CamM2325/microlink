/*
 * Host test for the Noise control-channel AEAD (src/ml_noise_aead.h), which
 * wraps wireguard-lwip's reference ChaCha20-Poly1305 with Tailscale's nonce
 * layout (4 zero bytes || big-endian 64-bit counter).
 *
 * Expected ciphertexts were produced by Python's `cryptography` package
 * (OpenSSL ChaCha20Poly1305) with nonce = b"\0"*4 + counter.to_bytes(8, "big").
 * Counter 0x0102030405060708 gives nonce 000000000102030405060708, the RFC 8439
 * appendix A.5 layout, so every nonce byte position is exercised.
 */
#include <stdio.h>
#include <stdint.h>
#include <stdlib.h>
#include <string.h>

#include "ml_noise_aead.h"

struct vec {
    uint64_t counter;
    const uint8_t *pt; size_t pt_len;
    const uint8_t *ad; size_t ad_len;
    const uint8_t *ct; size_t ct_len;
};

static const uint8_t KEY[32] = {
    0x80, 0x81, 0x82, 0x83, 0x84, 0x85, 0x86, 0x87, 0x88, 0x89, 0x8a, 0x8b,
    0x8c, 0x8d, 0x8e, 0x8f, 0x90, 0x91, 0x92, 0x93, 0x94, 0x95, 0x96, 0x97,
    0x98, 0x99, 0x9a, 0x9b, 0x9c, 0x9d, 0x9e, 0x9f
};
static const uint8_t PT0[] = { 0 };
static const uint8_t AD0[] = { 0 };
static const uint8_t CT0[] = {
    0x3a, 0xe5, 0xd3, 0xf2, 0xa3, 0x76, 0xd3, 0x17, 0xea, 0xea, 0x5a, 0xef,
    0x02, 0x15, 0xba, 0x54
};
static const uint8_t PT1[] = {
    0x00, 0x01, 0x02, 0x03, 0x04, 0x05, 0x06, 0x07, 0x08, 0x09, 0x0a, 0x0b,
    0x0c, 0x0d, 0x0e, 0x0f, 0x10, 0x11, 0x12, 0x13, 0x14, 0x15, 0x16, 0x17,
    0x18, 0x19, 0x1a, 0x1b, 0x1c, 0x1d, 0x1e, 0x1f
};
static const uint8_t AD1[] = {
    0x68, 0x68, 0x68, 0x68, 0x68, 0x68, 0x68, 0x68, 0x68, 0x68, 0x68, 0x68,
    0x68, 0x68, 0x68, 0x68, 0x68, 0x68, 0x68, 0x68, 0x68, 0x68, 0x68, 0x68,
    0x68, 0x68, 0x68, 0x68, 0x68, 0x68, 0x68, 0x68
};
static const uint8_t CT1[] = {
    0x2a, 0x5d, 0x18, 0xae, 0x3a, 0x5f, 0xe8, 0xcc, 0xc5, 0x38, 0x2f, 0xf4,
    0xa8, 0xd0, 0xa3, 0x25, 0x66, 0xd9, 0x78, 0xaa, 0xd7, 0x6f, 0xd7, 0x7f,
    0xbf, 0x2b, 0x48, 0xbd, 0x0f, 0x05, 0x15, 0x94, 0x83, 0xee, 0x90, 0x58,
    0x87, 0x07, 0xbc, 0x6c, 0xb0, 0x08, 0x4e, 0xd0, 0x43, 0x1e, 0x99, 0xd4
};
static const uint8_t PT2[] = {
    0x68, 0x65, 0x6c, 0x6c, 0x6f, 0x20, 0x6e, 0x6f, 0x69, 0x73, 0x65
};
static const uint8_t AD2[] = { 0 };
static const uint8_t CT2[] = {
    0x16, 0x0b, 0xad, 0xbe, 0xc6, 0xa7, 0x25, 0xf0, 0xa3, 0x15, 0x82, 0x24,
    0xd6, 0x7b, 0x9e, 0x0e, 0xb7, 0xb3, 0xaa, 0x37, 0xcb, 0x9f, 0xde, 0xac,
    0xbb, 0x29, 0xa4
};
static const uint8_t PT3[] = {
    0x00, 0x07, 0x0e, 0x15, 0x1c, 0x23, 0x2a, 0x31, 0x38, 0x3f, 0x46, 0x4d,
    0x54, 0x5b, 0x62, 0x69, 0x70, 0x77, 0x7e, 0x85, 0x8c, 0x93, 0x9a, 0xa1,
    0xa8, 0xaf, 0xb6, 0xbd, 0xc4, 0xcb, 0xd2, 0xd9, 0xe0, 0xe7, 0xee, 0xf5,
    0xfc, 0x03, 0x0a, 0x11, 0x18, 0x1f, 0x26, 0x2d, 0x34, 0x3b, 0x42, 0x49,
    0x50, 0x57, 0x5e, 0x65, 0x6c, 0x73, 0x7a, 0x81, 0x88, 0x8f, 0x96, 0x9d,
    0xa4, 0xab, 0xb2, 0xb9, 0xc0, 0xc7, 0xce, 0xd5, 0xdc, 0xe3, 0xea, 0xf1,
    0xf8, 0xff, 0x06, 0x0d, 0x14, 0x1b, 0x22, 0x29, 0x30, 0x37, 0x3e, 0x45,
    0x4c, 0x53, 0x5a, 0x61, 0x68, 0x6f, 0x76, 0x7d, 0x84, 0x8b, 0x92, 0x99,
    0xa0, 0xa7, 0xae, 0xb5, 0xbc, 0xc3, 0xca, 0xd1, 0xd8, 0xdf, 0xe6, 0xed,
    0xf4, 0xfb, 0x02, 0x09, 0x10, 0x17, 0x1e, 0x25, 0x2c, 0x33, 0x3a, 0x41,
    0x48, 0x4f, 0x56, 0x5d, 0x64, 0x6b, 0x72, 0x79, 0x80, 0x87
};
static const uint8_t AD3[] = {
    0x00, 0x01, 0x02, 0x03, 0x04, 0x05, 0x06, 0x07, 0x08, 0x09, 0x0a, 0x0b
};
static const uint8_t CT3[] = {
    0xe1, 0xbe, 0x1a, 0xed, 0x0b, 0xc6, 0x5d, 0xc9, 0x67, 0xa6, 0x25, 0xf1,
    0x6d, 0xb7, 0xdd, 0x49, 0xbe, 0xa4, 0xfd, 0x88, 0x1b, 0x4a, 0xe9, 0xce,
    0xd4, 0x4d, 0x04, 0x4d, 0x78, 0x48, 0x98, 0x61, 0x25, 0x01, 0x4b, 0x9d,
    0x16, 0x95, 0xdd, 0xf6, 0x3d, 0x6d, 0xf9, 0x25, 0x90, 0x7c, 0xc8, 0x16,
    0x4b, 0x48, 0x85, 0xe1, 0xf5, 0x7f, 0xd9, 0x59, 0x7a, 0x8d, 0x06, 0xa5,
    0x24, 0xd6, 0xf1, 0x56, 0x90, 0xdb, 0xae, 0x33, 0x11, 0xf8, 0x19, 0x20,
    0xc6, 0x00, 0x29, 0x9c, 0xb7, 0x97, 0x86, 0x12, 0xd4, 0xb2, 0x2c, 0x57,
    0x3f, 0xb4, 0x15, 0x68, 0x71, 0xad, 0xa4, 0x45, 0xa0, 0x61, 0xc4, 0xde,
    0x69, 0xf6, 0x71, 0x58, 0x46, 0x91, 0xf2, 0x5c, 0x11, 0xe8, 0x56, 0xc8,
    0x23, 0x47, 0xeb, 0x07, 0xb4, 0x61, 0x5d, 0x0d, 0x63, 0xa2, 0x7a, 0x7e,
    0x83, 0x45, 0x3c, 0xbf, 0xbc, 0x58, 0x15, 0xd3, 0x12, 0x23, 0xaa, 0xc8,
    0xf3, 0x23, 0xd5, 0x19, 0x75, 0x95, 0x62, 0xb2, 0x6a, 0x9f, 0xfc, 0xbc,
    0x81, 0xd6
};
static const uint8_t PT4[] = {
    0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78,
    0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78,
    0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78,
    0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78,
    0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78,
    0x78, 0x78, 0x78, 0x78
};
static const uint8_t AD4[] = {
    0x61, 0x64
};
static const uint8_t CT4[] = {
    0xe9, 0x32, 0xe5, 0x8c, 0xf6, 0x0f, 0xad, 0xe2, 0x91, 0xfc, 0x3d, 0x1a,
    0x01, 0x09, 0xbe, 0xc0, 0xea, 0x0c, 0xc1, 0x17, 0xe5, 0xd1, 0xbe, 0x5f,
    0x16, 0xa7, 0xaa, 0xd9, 0x8d, 0xce, 0x58, 0xf1, 0x17, 0x60, 0xc0, 0xf3,
    0x05, 0x35, 0x0c, 0x6c, 0x5b, 0x95, 0x82, 0xd1, 0x55, 0x90, 0x35, 0x5e,
    0x0b, 0x72, 0x0f, 0x67, 0xd5, 0x0d, 0x81, 0xb9, 0xe3, 0xe4, 0xa9, 0x2a,
    0x91, 0xd4, 0x22, 0xab, 0x4d, 0x73, 0x43, 0x17, 0xaa, 0xb8, 0xce, 0xf2,
    0x4a, 0x70, 0x79, 0x5b, 0xc1, 0x5e, 0xa7, 0x54
};
static const uint8_t PT5[] = {
    0x74, 0x61, 0x69, 0x6c
};
static const uint8_t AD5[] = { 0 };
static const uint8_t CT5[] = {
    0xcf, 0x07, 0xaa, 0x01, 0x32, 0xab, 0xdf, 0x15, 0xde, 0xe7, 0xc5, 0x55,
    0x19, 0xf3, 0x2e, 0x4b, 0xd5, 0x82, 0xf0, 0x06
};
static const struct vec VECS[] = {
    { 0x0000000000000000ULL, PT0, 0, AD0, 0, CT0, 16 },
    { 0x0000000000000000ULL, PT1, 32, AD1, 32, CT1, 48 },
    { 0x0000000000000001ULL, PT2, 11, AD2, 0, CT2, 27 },
    { 0x0102030405060708ULL, PT3, 130, AD3, 12, CT3, 146 },
    { 0x0000000100000005ULL, PT4, 64, AD4, 2, CT4, 80 },
    { 0xfffffffffffffffeULL, PT5, 4, AD5, 0, CT5, 20 },
};

static int failures;

#define CHECK(cond, ...) do { \
    if (!(cond)) { failures++; printf("FAIL %s:%d: ", __FILE__, __LINE__); \
                   printf(__VA_ARGS__); printf("\n"); } } while (0)

int main(void)
{
    for (size_t i = 0; i < sizeof(VECS) / sizeof(VECS[0]); i++) {
        const struct vec *v = &VECS[i];
        uint8_t buf[256];
        uint8_t out[256];

        /* Seal and compare against the reference ciphertext + tag */
        memset(buf, 0xAA, sizeof(buf));
        CHECK(noise_aead_encrypt(KEY, v->counter, v->ad_len ? v->ad : NULL, v->ad_len,
                                 v->pt_len ? v->pt : NULL, v->pt_len, buf) == 0,
              "vec %zu: encrypt returned error", i);
        CHECK(memcmp(buf, v->ct, v->ct_len) == 0, "vec %zu: ciphertext mismatch", i);

        /* Open */
        memset(out, 0xAA, sizeof(out));
        CHECK(noise_aead_decrypt(KEY, v->counter, v->ad_len ? v->ad : NULL, v->ad_len,
                                 v->ct, v->ct_len, v->pt_len ? out : NULL) == 0,
              "vec %zu: decrypt rejected valid message", i);
        CHECK(memcmp(out, v->pt, v->pt_len) == 0, "vec %zu: plaintext mismatch", i);

        /* In place, as ml_coord may do */
        memcpy(buf, v->pt, v->pt_len);
        noise_aead_encrypt(KEY, v->counter, v->ad, v->ad_len, buf, v->pt_len, buf);
        CHECK(memcmp(buf, v->ct, v->ct_len) == 0, "vec %zu: in-place encrypt mismatch", i);
        CHECK(noise_aead_decrypt(KEY, v->counter, v->ad, v->ad_len, buf, v->ct_len, buf) == 0 &&
              memcmp(buf, v->pt, v->pt_len) == 0, "vec %zu: in-place decrypt failed", i);

        /* Tampering: every ciphertext/tag byte, wrong counter, wrong AD */
        for (size_t j = 0; j < v->ct_len; j++) {
            memcpy(buf, v->ct, v->ct_len);
            buf[j] ^= 0x01;
            memset(out, 0xAA, sizeof(out));
            CHECK(noise_aead_decrypt(KEY, v->counter, v->ad, v->ad_len, buf, v->ct_len, out) != 0,
                  "vec %zu: flipped byte %zu accepted", i, j);
            CHECK(out[0] == 0xAA, "vec %zu: plaintext written on auth failure", i);
        }
        CHECK(noise_aead_decrypt(KEY, v->counter + 1, v->ad, v->ad_len, v->ct, v->ct_len, out) != 0,
              "vec %zu: wrong counter accepted", i);
        uint8_t ad2[64] = { 0 };
        memcpy(ad2, v->ad, v->ad_len);
        ad2[0] ^= 0x80;
        CHECK(noise_aead_decrypt(KEY, v->counter, ad2, v->ad_len ? v->ad_len : 1,
                                 v->ct, v->ct_len, out) != 0,
              "vec %zu: wrong AD accepted", i);
    }

    /* Shorter than a tag */
    uint8_t out[16];
    CHECK(noise_aead_decrypt(KEY, 0, NULL, 0, CT0, 15, out) != 0, "15-byte message accepted");
    CHECK(noise_aead_decrypt(KEY, 0, NULL, 0, CT0, 0, out) != 0, "empty message accepted");

    if (failures) {
        printf("%d failure(s)\n", failures);
        return 1;
    }
    printf("noise_aead: all tests passed\n");
    return 0;
}
