/*
 * Known-answer tests for the crypto that MicroLink compiles with -O2
 * (see the set_source_files_properties() calls in the component CMakeLists):
 *
 *   X25519             wireguard-lwip crypto/refc/x25519.c   RFC 7748 5.2, 5.2 iterated, 6.1
 *   ChaCha20-Poly1305  crypto/refc/chacha20poly1305.c        RFC 8439 A.5
 *   Poly1305           crypto/refc/poly1305-donna.c          RFC 8439 2.5.2
 *   BLAKE2s            crypto/refc/blake2s.c                 RFC 7693 appendix B and E
 *   NaCl crypto_box    microlink src/nacl_box.c              NaCl "firstkey" + libsodium
 *
 * The test is built once per optimisation level listed in CMakeLists.txt, so
 * optimiser-sensitive undefined behaviour in the vendored crypto shows up here
 * before it ships. The crypto_box ciphertexts were produced with libsodium
 * crypto_box_easy() (MAC || ciphertext, the layout nacl_box() writes).
 */
#include <stdio.h>
#include <stdint.h>
#include <stdlib.h>
#include <string.h>

#include "x25519.h"
#include "chacha20poly1305.h"
#include "poly1305-donna.h"
#include "blake2s.h"
#include "nacl_box.h"

static int failures;

#define CHECK(cond, ...) do { \
    if (!(cond)) { failures++; printf("FAIL %s:%d: ", __FILE__, __LINE__); \
                   printf(__VA_ARGS__); printf("\n"); } } while (0)

/* ---- X25519 (RFC 7748) ---------------------------------------------- */
static const uint8_t X_SCALAR1[32] = {
    0xa5, 0x46, 0xe3, 0x6b, 0xf0, 0x52, 0x7c, 0x9d, 0x3b, 0x16, 0x15, 0x4b,
    0x82, 0x46, 0x5e, 0xdd, 0x62, 0x14, 0x4c, 0x0a, 0xc1, 0xfc, 0x5a, 0x18,
    0x50, 0x6a, 0x22, 0x44, 0xba, 0x44, 0x9a, 0xc4
};
static const uint8_t X_U1[32] = {
    0xe6, 0xdb, 0x68, 0x67, 0x58, 0x30, 0x30, 0xdb, 0x35, 0x94, 0xc1, 0xa4,
    0x24, 0xb1, 0x5f, 0x7c, 0x72, 0x66, 0x24, 0xec, 0x26, 0xb3, 0x35, 0x3b,
    0x10, 0xa9, 0x03, 0xa6, 0xd0, 0xab, 0x1c, 0x4c
};
static const uint8_t X_OUT1[32] = {
    0xc3, 0xda, 0x55, 0x37, 0x9d, 0xe9, 0xc6, 0x90, 0x8e, 0x94, 0xea, 0x4d,
    0xf2, 0x8d, 0x08, 0x4f, 0x32, 0xec, 0xcf, 0x03, 0x49, 0x1c, 0x71, 0xf7,
    0x54, 0xb4, 0x07, 0x55, 0x77, 0xa2, 0x85, 0x52
};
static const uint8_t X_SCALAR2[32] = {
    0x4b, 0x66, 0xe9, 0xd4, 0xd1, 0xb4, 0x67, 0x3c, 0x5a, 0xd2, 0x26, 0x91,
    0x95, 0x7d, 0x6a, 0xf5, 0xc1, 0x1b, 0x64, 0x21, 0xe0, 0xea, 0x01, 0xd4,
    0x2c, 0xa4, 0x16, 0x9e, 0x79, 0x18, 0xba, 0x0d
};
static const uint8_t X_U2[32] = {
    0xe5, 0x21, 0x0f, 0x12, 0x78, 0x68, 0x11, 0xd3, 0xf4, 0xb7, 0x95, 0x9d,
    0x05, 0x38, 0xae, 0x2c, 0x31, 0xdb, 0xe7, 0x10, 0x6f, 0xc0, 0x3c, 0x3e,
    0xfc, 0x4c, 0xd5, 0x49, 0xc7, 0x15, 0xa4, 0x93
};
static const uint8_t X_OUT2[32] = {
    0x95, 0xcb, 0xde, 0x94, 0x76, 0xe8, 0x90, 0x7d, 0x7a, 0xad, 0xe4, 0x5c,
    0xb4, 0xb8, 0x73, 0xf8, 0x8b, 0x59, 0x5a, 0x68, 0x79, 0x9f, 0xa1, 0x52,
    0xe6, 0xf8, 0xf7, 0x64, 0x7a, 0xac, 0x79, 0x57
};
static const uint8_t X_ITER1[32] = {
    0x42, 0x2c, 0x8e, 0x7a, 0x62, 0x27, 0xd7, 0xbc, 0xa1, 0x35, 0x0b, 0x3e,
    0x2b, 0xb7, 0x27, 0x9f, 0x78, 0x97, 0xb8, 0x7b, 0xb6, 0x85, 0x4b, 0x78,
    0x3c, 0x60, 0xe8, 0x03, 0x11, 0xae, 0x30, 0x79
};
static const uint8_t X_ITER1000[32] = {
    0x68, 0x4c, 0xf5, 0x9b, 0xa8, 0x33, 0x09, 0x55, 0x28, 0x00, 0xef, 0x56,
    0x6f, 0x2f, 0x4d, 0x3c, 0x1c, 0x38, 0x87, 0xc4, 0x93, 0x60, 0xe3, 0x87,
    0x5f, 0x2e, 0xb9, 0x4d, 0x99, 0x53, 0x2c, 0x51
};
static const uint8_t ALICE_SK[32] = {
    0x77, 0x07, 0x6d, 0x0a, 0x73, 0x18, 0xa5, 0x7d, 0x3c, 0x16, 0xc1, 0x72,
    0x51, 0xb2, 0x66, 0x45, 0xdf, 0x4c, 0x2f, 0x87, 0xeb, 0xc0, 0x99, 0x2a,
    0xb1, 0x77, 0xfb, 0xa5, 0x1d, 0xb9, 0x2c, 0x2a
};
static const uint8_t ALICE_PK[32] = {
    0x85, 0x20, 0xf0, 0x09, 0x89, 0x30, 0xa7, 0x54, 0x74, 0x8b, 0x7d, 0xdc,
    0xb4, 0x3e, 0xf7, 0x5a, 0x0d, 0xbf, 0x3a, 0x0d, 0x26, 0x38, 0x1a, 0xf4,
    0xeb, 0xa4, 0xa9, 0x8e, 0xaa, 0x9b, 0x4e, 0x6a
};
static const uint8_t BOB_SK[32] = {
    0x5d, 0xab, 0x08, 0x7e, 0x62, 0x4a, 0x8a, 0x4b, 0x79, 0xe1, 0x7f, 0x8b,
    0x83, 0x80, 0x0e, 0xe6, 0x6f, 0x3b, 0xb1, 0x29, 0x26, 0x18, 0xb6, 0xfd,
    0x1c, 0x2f, 0x8b, 0x27, 0xff, 0x88, 0xe0, 0xeb
};
static const uint8_t BOB_PK[32] = {
    0xde, 0x9e, 0xdb, 0x7d, 0x7b, 0x7d, 0xc1, 0xb4, 0xd3, 0x5b, 0x61, 0xc2,
    0xec, 0xe4, 0x35, 0x37, 0x3f, 0x83, 0x43, 0xc8, 0x5b, 0x78, 0x67, 0x4d,
    0xad, 0xfc, 0x7e, 0x14, 0x6f, 0x88, 0x2b, 0x4f
};
static const uint8_t DH_SHARED[32] = {
    0x4a, 0x5d, 0x9d, 0x5b, 0xa4, 0xce, 0x2d, 0xe1, 0x72, 0x8e, 0x3b, 0xf4,
    0x80, 0x35, 0x0f, 0x25, 0xe0, 0x7e, 0x21, 0xc9, 0x47, 0xd1, 0x9e, 0x33,
    0x76, 0xf0, 0x9b, 0x3c, 0x1e, 0x16, 0x17, 0x42
};

static void test_x25519(void)
{
    uint8_t out[32], u[32];

    CHECK(x25519(out, X_SCALAR1, X_U1, 1) == 0 && memcmp(out, X_OUT1, 32) == 0,
          "x25519: RFC 7748 5.2 vector 1");

    /* RFC 7748 says to ignore the top bit of u; this implementation does not
     * (see x25519.h), so the caller masks it, as WireGuard keys never set it. */
    memcpy(u, X_U2, 32);
    u[31] &= 0x7f;
    CHECK(x25519(out, X_SCALAR2, u, 1) == 0 && memcmp(out, X_OUT2, 32) == 0,
          "x25519: RFC 7748 5.2 vector 2");

    /* 5.2 iterated: k = X25519(k, u), u = old k, starting from k = u = 9 */
    uint8_t k[32] = { 9 }, uu[32] = { 9 }, r[32];
    for (int i = 1; i <= 1000; i++) {
        x25519(r, k, uu, 1);
        memcpy(uu, k, 32);
        memcpy(k, r, 32);
        if (i == 1)
            CHECK(memcmp(k, X_ITER1, 32) == 0, "x25519: RFC 7748 iterated x1");
    }
    CHECK(memcmp(k, X_ITER1000, 32) == 0, "x25519: RFC 7748 iterated x1000");

    /* 6.1 Diffie-Hellman */
    CHECK(x25519_base(out, ALICE_SK, 1) == 0 && memcmp(out, ALICE_PK, 32) == 0,
          "x25519: RFC 7748 6.1 Alice public key");
    CHECK(x25519_base(out, BOB_SK, 1) == 0 && memcmp(out, BOB_PK, 32) == 0,
          "x25519: RFC 7748 6.1 Bob public key");
    CHECK(x25519(out, ALICE_SK, BOB_PK, 1) == 0 && memcmp(out, DH_SHARED, 32) == 0,
          "x25519: RFC 7748 6.1 shared secret (Alice)");
    CHECK(x25519(out, BOB_SK, ALICE_PK, 1) == 0 && memcmp(out, DH_SHARED, 32) == 0,
          "x25519: RFC 7748 6.1 shared secret (Bob)");

    /* Non-contributory (all-zero) output must be reported */
    uint8_t zero[32] = { 0 };
    CHECK(x25519(out, ALICE_SK, zero, 1) != 0, "x25519: zero point not rejected");
}

/* ---- ChaCha20-Poly1305 (RFC 8439 A.5) -------------------------------- */
static const uint8_t A5_KEY[32] = {
    0x1c, 0x92, 0x40, 0xa5, 0xeb, 0x55, 0xd3, 0x8a, 0xf3, 0x33, 0x88, 0x86,
    0x04, 0xf6, 0xb5, 0xf0, 0x47, 0x39, 0x17, 0xc1, 0x40, 0x2b, 0x80, 0x09,
    0x9d, 0xca, 0x5c, 0xbc, 0x20, 0x70, 0x75, 0xc0
};
static const uint8_t A5_AAD[12] = {
    0xf3, 0x33, 0x88, 0x86, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x4e, 0x91
};
static const uint8_t A5_PT[265] = {
    0x49, 0x6e, 0x74, 0x65, 0x72, 0x6e, 0x65, 0x74, 0x2d, 0x44, 0x72, 0x61,
    0x66, 0x74, 0x73, 0x20, 0x61, 0x72, 0x65, 0x20, 0x64, 0x72, 0x61, 0x66,
    0x74, 0x20, 0x64, 0x6f, 0x63, 0x75, 0x6d, 0x65, 0x6e, 0x74, 0x73, 0x20,
    0x76, 0x61, 0x6c, 0x69, 0x64, 0x20, 0x66, 0x6f, 0x72, 0x20, 0x61, 0x20,
    0x6d, 0x61, 0x78, 0x69, 0x6d, 0x75, 0x6d, 0x20, 0x6f, 0x66, 0x20, 0x73,
    0x69, 0x78, 0x20, 0x6d, 0x6f, 0x6e, 0x74, 0x68, 0x73, 0x20, 0x61, 0x6e,
    0x64, 0x20, 0x6d, 0x61, 0x79, 0x20, 0x62, 0x65, 0x20, 0x75, 0x70, 0x64,
    0x61, 0x74, 0x65, 0x64, 0x2c, 0x20, 0x72, 0x65, 0x70, 0x6c, 0x61, 0x63,
    0x65, 0x64, 0x2c, 0x20, 0x6f, 0x72, 0x20, 0x6f, 0x62, 0x73, 0x6f, 0x6c,
    0x65, 0x74, 0x65, 0x64, 0x20, 0x62, 0x79, 0x20, 0x6f, 0x74, 0x68, 0x65,
    0x72, 0x20, 0x64, 0x6f, 0x63, 0x75, 0x6d, 0x65, 0x6e, 0x74, 0x73, 0x20,
    0x61, 0x74, 0x20, 0x61, 0x6e, 0x79, 0x20, 0x74, 0x69, 0x6d, 0x65, 0x2e,
    0x20, 0x49, 0x74, 0x20, 0x69, 0x73, 0x20, 0x69, 0x6e, 0x61, 0x70, 0x70,
    0x72, 0x6f, 0x70, 0x72, 0x69, 0x61, 0x74, 0x65, 0x20, 0x74, 0x6f, 0x20,
    0x75, 0x73, 0x65, 0x20, 0x49, 0x6e, 0x74, 0x65, 0x72, 0x6e, 0x65, 0x74,
    0x2d, 0x44, 0x72, 0x61, 0x66, 0x74, 0x73, 0x20, 0x61, 0x73, 0x20, 0x72,
    0x65, 0x66, 0x65, 0x72, 0x65, 0x6e, 0x63, 0x65, 0x20, 0x6d, 0x61, 0x74,
    0x65, 0x72, 0x69, 0x61, 0x6c, 0x20, 0x6f, 0x72, 0x20, 0x74, 0x6f, 0x20,
    0x63, 0x69, 0x74, 0x65, 0x20, 0x74, 0x68, 0x65, 0x6d, 0x20, 0x6f, 0x74,
    0x68, 0x65, 0x72, 0x20, 0x74, 0x68, 0x61, 0x6e, 0x20, 0x61, 0x73, 0x20,
    0x2f, 0xe2, 0x80, 0x9c, 0x77, 0x6f, 0x72, 0x6b, 0x20, 0x69, 0x6e, 0x20,
    0x70, 0x72, 0x6f, 0x67, 0x72, 0x65, 0x73, 0x73, 0x2e, 0x2f, 0xe2, 0x80,
    0x9d
};
static const uint8_t A5_CT[281] = {
    0x64, 0xa0, 0x86, 0x15, 0x75, 0x86, 0x1a, 0xf4, 0x60, 0xf0, 0x62, 0xc7,
    0x9b, 0xe6, 0x43, 0xbd, 0x5e, 0x80, 0x5c, 0xfd, 0x34, 0x5c, 0xf3, 0x89,
    0xf1, 0x08, 0x67, 0x0a, 0xc7, 0x6c, 0x8c, 0xb2, 0x4c, 0x6c, 0xfc, 0x18,
    0x75, 0x5d, 0x43, 0xee, 0xa0, 0x9e, 0xe9, 0x4e, 0x38, 0x2d, 0x26, 0xb0,
    0xbd, 0xb7, 0xb7, 0x3c, 0x32, 0x1b, 0x01, 0x00, 0xd4, 0xf0, 0x3b, 0x7f,
    0x35, 0x58, 0x94, 0xcf, 0x33, 0x2f, 0x83, 0x0e, 0x71, 0x0b, 0x97, 0xce,
    0x98, 0xc8, 0xa8, 0x4a, 0xbd, 0x0b, 0x94, 0x81, 0x14, 0xad, 0x17, 0x6e,
    0x00, 0x8d, 0x33, 0xbd, 0x60, 0xf9, 0x82, 0xb1, 0xff, 0x37, 0xc8, 0x55,
    0x97, 0x97, 0xa0, 0x6e, 0xf4, 0xf0, 0xef, 0x61, 0xc1, 0x86, 0x32, 0x4e,
    0x2b, 0x35, 0x06, 0x38, 0x36, 0x06, 0x90, 0x7b, 0x6a, 0x7c, 0x02, 0xb0,
    0xf9, 0xf6, 0x15, 0x7b, 0x53, 0xc8, 0x67, 0xe4, 0xb9, 0x16, 0x6c, 0x76,
    0x7b, 0x80, 0x4d, 0x46, 0xa5, 0x9b, 0x52, 0x16, 0xcd, 0xe7, 0xa4, 0xe9,
    0x90, 0x40, 0xc5, 0xa4, 0x04, 0x33, 0x22, 0x5e, 0xe2, 0x82, 0xa1, 0xb0,
    0xa0, 0x6c, 0x52, 0x3e, 0xaf, 0x45, 0x34, 0xd7, 0xf8, 0x3f, 0xa1, 0x15,
    0x5b, 0x00, 0x47, 0x71, 0x8c, 0xbc, 0x54, 0x6a, 0x0d, 0x07, 0x2b, 0x04,
    0xb3, 0x56, 0x4e, 0xea, 0x1b, 0x42, 0x22, 0x73, 0xf5, 0x48, 0x27, 0x1a,
    0x0b, 0xb2, 0x31, 0x60, 0x53, 0xfa, 0x76, 0x99, 0x19, 0x55, 0xeb, 0xd6,
    0x31, 0x59, 0x43, 0x4e, 0xce, 0xbb, 0x4e, 0x46, 0x6d, 0xae, 0x5a, 0x10,
    0x73, 0xa6, 0x72, 0x76, 0x27, 0x09, 0x7a, 0x10, 0x49, 0xe6, 0x17, 0xd9,
    0x1d, 0x36, 0x10, 0x94, 0xfa, 0x68, 0xf0, 0xff, 0x77, 0x98, 0x71, 0x30,
    0x30, 0x5b, 0xea, 0xba, 0x2e, 0xda, 0x04, 0xdf, 0x99, 0x7b, 0x71, 0x4d,
    0x6c, 0x6f, 0x2c, 0x29, 0xa6, 0xad, 0x5c, 0xb4, 0x02, 0x2b, 0x02, 0x70,
    0x9b, 0xee, 0xad, 0x9d, 0x67, 0x89, 0x0c, 0xbb, 0x22, 0x39, 0x23, 0x36,
    0xfe, 0xa1, 0x85, 0x1f, 0x38
};

static void test_chacha20poly1305(void)
{
    /* wireguard-lwip takes the nonce as 4 zero bytes || 64-bit little-endian
     * counter. RFC 8439 A.5 uses nonce 00000000 01020304 05060708. */
    const uint64_t nonce = 0x0807060504030201ULL;
    uint8_t buf[sizeof(A5_CT)], out[sizeof(A5_PT)];

    chacha20poly1305_encrypt(buf, A5_PT, sizeof(A5_PT), A5_AAD, sizeof(A5_AAD), nonce, A5_KEY);
    CHECK(memcmp(buf, A5_CT, sizeof(A5_CT)) == 0, "chachapoly: RFC 8439 A.5 seal");

    memset(out, 0, sizeof(out));
    CHECK(chacha20poly1305_decrypt(out, A5_CT, sizeof(A5_CT), A5_AAD, sizeof(A5_AAD), nonce, A5_KEY) &&
          memcmp(out, A5_PT, sizeof(A5_PT)) == 0, "chachapoly: RFC 8439 A.5 open");

    memcpy(buf, A5_CT, sizeof(A5_CT));
    buf[sizeof(buf) - 1] ^= 0x01;
    CHECK(!chacha20poly1305_decrypt(out, buf, sizeof(buf), A5_AAD, sizeof(A5_AAD), nonce, A5_KEY),
          "chachapoly: corrupted tag accepted");
    memcpy(buf, A5_CT, sizeof(A5_CT));
    buf[100] ^= 0x80;
    CHECK(!chacha20poly1305_decrypt(out, buf, sizeof(buf), A5_AAD, sizeof(A5_AAD), nonce, A5_KEY),
          "chachapoly: corrupted ciphertext accepted");
    CHECK(!chacha20poly1305_decrypt(out, A5_CT, sizeof(A5_CT), A5_AAD, sizeof(A5_AAD), nonce + 1, A5_KEY),
          "chachapoly: wrong nonce accepted");
}

/* ---- Poly1305 (RFC 8439 2.5.2) --------------------------------------- */
static const uint8_t P_KEY[32] = {
    0x85, 0xd6, 0xbe, 0x78, 0x57, 0x55, 0x6d, 0x33, 0x7f, 0x44, 0x52, 0xfe,
    0x42, 0xd5, 0x06, 0xa8, 0x01, 0x03, 0x80, 0x8a, 0xfb, 0x0d, 0xb2, 0xfd,
    0x4a, 0xbf, 0xf6, 0xaf, 0x41, 0x49, 0xf5, 0x1b
};
static const uint8_t P_TAG[16] = {
    0xa8, 0x06, 0x1d, 0xc1, 0x30, 0x51, 0x36, 0xc6, 0xc2, 0x2b, 0x8b, 0xaf,
    0x0c, 0x01, 0x27, 0xa9
};

static void test_poly1305(void)
{
    static const char msg[] = "Cryptographic Forum Research Group";
    poly1305_context ctx;
    uint8_t mac[16];

    poly1305_init(&ctx, P_KEY);
    poly1305_update(&ctx, (const unsigned char *)msg, sizeof(msg) - 1);
    poly1305_finish(&ctx, mac);
    CHECK(memcmp(mac, P_TAG, 16) == 0, "poly1305: RFC 8439 2.5.2 (one update)");

    /* Same message fed in uneven pieces exercises the partial-block buffer */
    poly1305_init(&ctx, P_KEY);
    poly1305_update(&ctx, (const unsigned char *)msg, 5);
    poly1305_update(&ctx, (const unsigned char *)msg + 5, 17);
    poly1305_update(&ctx, (const unsigned char *)msg + 22, sizeof(msg) - 1 - 22);
    poly1305_finish(&ctx, mac);
    CHECK(memcmp(mac, P_TAG, 16) == 0, "poly1305: RFC 8439 2.5.2 (split updates)");
}

/* ---- BLAKE2s (RFC 7693) ---------------------------------------------- */
static const uint8_t B2S_ABC[32] = {
    0x50, 0x8c, 0x5e, 0x8c, 0x32, 0x7c, 0x14, 0xe2, 0xe1, 0xa7, 0x2b, 0xa3,
    0x4e, 0xeb, 0x45, 0x2f, 0x37, 0x45, 0x8b, 0x20, 0x9e, 0xd6, 0x3a, 0x29,
    0x4d, 0x99, 0x9b, 0x4c, 0x86, 0x67, 0x59, 0x82
};
static const uint8_t B2S_SELFTEST[32] = {
    0x6a, 0x41, 0x1f, 0x08, 0xce, 0x25, 0xad, 0xcd, 0xfb, 0x02, 0xab, 0xa6,
    0x41, 0x45, 0x1c, 0xec, 0x53, 0xc5, 0x98, 0xb2, 0x4f, 0x4f, 0xc7, 0x87,
    0xfb, 0xdc, 0x88, 0x79, 0x7f, 0x4c, 0x1d, 0xfe
};

/* RFC 7693 appendix E: deterministic input sequence */
static void selftest_seq(uint8_t *out, size_t len, uint32_t seed)
{
    uint32_t t, a = 0xDEAD4BAD * seed, b = 1;
    for (size_t i = 0; i < len; i++) {
        t = a + b;
        a = b;
        b = t;
        out[i] = (t >> 24) & 0xFF;
    }
}

static void test_blake2s(void)
{
    uint8_t md[32];

    CHECK(blake2s(md, 32, NULL, 0, "abc", 3) == 0 && memcmp(md, B2S_ABC, 32) == 0,
          "blake2s: RFC 7693 appendix B (\"abc\")");

    /* RFC 7693 appendix E: hash of keyed and unkeyed hashes over several
     * digest and input lengths */
    static const size_t md_len[4] = { 16, 20, 28, 32 };
    static const size_t in_len[6] = { 0, 3, 64, 65, 255, 1024 };
    uint8_t in[1024], key[32];
    blake2s_ctx ctx;

    CHECK(blake2s_init(&ctx, 32, NULL, 0) == 0, "blake2s: init");
    for (size_t i = 0; i < 4; i++) {
        size_t outlen = md_len[i];
        for (size_t j = 0; j < 6; j++) {
            size_t inlen = in_len[j];
            selftest_seq(in, inlen, (uint32_t)inlen);
            blake2s(md, outlen, NULL, 0, in, inlen);
            blake2s_update(&ctx, md, outlen);
            selftest_seq(key, outlen, (uint32_t)outlen);
            blake2s(md, outlen, key, outlen, in, inlen);
            blake2s_update(&ctx, md, outlen);
        }
    }
    blake2s_final(&ctx, md);
    CHECK(memcmp(md, B2S_SELFTEST, 32) == 0, "blake2s: RFC 7693 appendix E self-test");
}

/* ---- NaCl crypto_box (DISCO) ----------------------------------------- */
static const uint8_t BOX_FIRSTKEY[32] = {
    0x1b, 0x27, 0x55, 0x64, 0x73, 0xe9, 0x85, 0xd4, 0x62, 0xcd, 0x51, 0x19,
    0x7a, 0x9a, 0x46, 0xc7, 0x60, 0x09, 0x54, 0x9e, 0xac, 0x64, 0x74, 0xf2,
    0x06, 0xc4, 0xee, 0x08, 0x44, 0xf6, 0x83, 0x89
};
static const uint8_t BOX_NONCE[24] = {
    0x69, 0x69, 0x6e, 0xe9, 0x55, 0xb6, 0x2b, 0x73, 0xcd, 0x62, 0xbd, 0xa8,
    0x75, 0xfc, 0x73, 0xd6, 0x82, 0x19, 0xe0, 0x03, 0x6b, 0x7a, 0x0b, 0x37
};
static const uint8_t BOX_CT0[16] = {
    0x25, 0x39, 0x12, 0x1d, 0x8e, 0x23, 0x4e, 0x65, 0x2d, 0x65, 0x1f, 0xa4,
    0xc8, 0xcf, 0xf8, 0x80
};
static const uint8_t BOX_CT131[147] = {
    0x24, 0x78, 0x2d, 0x15, 0xd1, 0xca, 0x84, 0xf6, 0xb9, 0x80, 0x72, 0x53,
    0x9a, 0xa1, 0x95, 0xc1, 0x33, 0x94, 0x75, 0x42, 0x6b, 0xcf, 0xcd, 0x92,
    0x36, 0xc0, 0x0a, 0xfc, 0x8e, 0x49, 0x1f, 0xd9, 0x69, 0x61, 0x6a, 0x05,
    0xd5, 0xb9, 0xc0, 0xd4, 0xa7, 0xbb, 0x85, 0x9e, 0x92, 0x4b, 0x82, 0x4a,
    0xc6, 0xd9, 0x8a, 0x2b, 0x54, 0x67, 0x90, 0x75, 0x4c, 0x42, 0xf1, 0xf5,
    0x85, 0x1a, 0xed, 0x17, 0x4e, 0x54, 0x9f, 0x66, 0xd7, 0xd1, 0x93, 0x92,
    0xb1, 0x29, 0x9a, 0xd6, 0xf5, 0x31, 0x79, 0xb5, 0x79, 0x7f, 0xd7, 0x1e,
    0xc7, 0x07, 0xd1, 0x13, 0x8c, 0xda, 0x25, 0x2a, 0xfe, 0xcf, 0x83, 0xd5,
    0x41, 0xee, 0x57, 0x4a, 0xc8, 0x9d, 0xa3, 0x04, 0xd4, 0x53, 0x49, 0x7c,
    0x8d, 0xe1, 0x63, 0x98, 0x3e, 0xa0, 0xed, 0x32, 0x3d, 0x32, 0xe4, 0xf7,
    0xc4, 0xe2, 0x69, 0x72, 0x1f, 0xbb, 0xd2, 0xed, 0x9a, 0xc9, 0x5e, 0xb6,
    0xfd, 0x82, 0x59, 0xa2, 0xf2, 0x4b, 0xbf, 0x32, 0x5d, 0xe2, 0x67, 0x6c,
    0x3e, 0xd8, 0x31
};
static const uint8_t BOX_CT200[216] = {
    0x70, 0xcc, 0xa9, 0x74, 0x0c, 0x13, 0xfe, 0x6a, 0x7f, 0x70, 0xba, 0xcb,
    0x5c, 0x50, 0x74, 0xae, 0x33, 0x94, 0x75, 0x42, 0x6b, 0xcf, 0xcd, 0x92,
    0x36, 0xc0, 0x0a, 0xfc, 0x8e, 0x49, 0x1f, 0xd9, 0x69, 0x61, 0x6a, 0x05,
    0xd5, 0xb9, 0xc0, 0xd4, 0xa7, 0xbb, 0x85, 0x9e, 0x92, 0x4b, 0x82, 0x4a,
    0xc6, 0xd9, 0x8a, 0x2b, 0x54, 0x67, 0x90, 0x75, 0x4c, 0x42, 0xf1, 0xf5,
    0x85, 0x1a, 0xed, 0x17, 0x4e, 0x54, 0x9f, 0x66, 0xd7, 0xd1, 0x93, 0x92,
    0xb1, 0x29, 0x9a, 0xd6, 0xf5, 0x31, 0x79, 0xb5, 0x79, 0x7f, 0xd7, 0x1e,
    0xc7, 0x07, 0xd1, 0x13, 0x8c, 0xda, 0x25, 0x2a, 0xfe, 0xcf, 0x83, 0xd5,
    0x41, 0xee, 0x57, 0x4a, 0xc8, 0x9d, 0xa3, 0x04, 0xd4, 0x53, 0x49, 0x7c,
    0x8d, 0xe1, 0x63, 0x98, 0x3e, 0xa0, 0xed, 0x32, 0x3d, 0x32, 0xe4, 0xf7,
    0xc4, 0xe2, 0x69, 0x72, 0x1f, 0xbb, 0xd2, 0xed, 0x9a, 0xc9, 0x5e, 0xb6,
    0xfd, 0x82, 0x59, 0xa2, 0xf2, 0x4b, 0xbf, 0x32, 0x5d, 0xe2, 0x67, 0x6c,
    0x3e, 0xd8, 0x31, 0xb2, 0xd3, 0x99, 0x49, 0xb2, 0x68, 0xca, 0x96, 0x80,
    0xbf, 0x0f, 0x75, 0x72, 0x1d, 0x30, 0x62, 0x61, 0xa4, 0xdf, 0x9c, 0x80,
    0x05, 0xb5, 0xc7, 0x26, 0x12, 0xcd, 0xa5, 0xf7, 0xe6, 0xc4, 0x00, 0x8e,
    0x87, 0xc9, 0xdf, 0x1a, 0xf0, 0x9b, 0xd3, 0x48, 0xd8, 0xd7, 0xd2, 0x15,
    0xa6, 0x91, 0x92, 0xc8, 0x34, 0x2a, 0xd2, 0xee, 0x8a, 0x5b, 0x76, 0x07,
    0x15, 0xdb, 0x07, 0x90, 0x3b, 0x8e, 0xb8, 0x9e, 0x90, 0xd7, 0xe2, 0xfa
};

static void box_msg(uint8_t *m, size_t len)
{
    for (size_t i = 0; i < len; i++)
        m[i] = (uint8_t)(i * 7 + 3);
}

static void test_nacl_box(void)
{
    static const struct { size_t len; const uint8_t *ct; } V[] = {
        { 0, BOX_CT0 }, { 131, BOX_CT131 }, { 200, BOX_CT200 },
    };
    uint8_t k[32], k2[32], m[256], c[256 + 16], p[256];

    CHECK(nacl_box_beforenm(k, BOB_PK, ALICE_SK) == 0 && memcmp(k, BOX_FIRSTKEY, 32) == 0,
          "nacl: beforenm(bobpk, alicesk) != NaCl firstkey");
    CHECK(nacl_box_beforenm(k2, ALICE_PK, BOB_SK) == 0 && memcmp(k2, BOX_FIRSTKEY, 32) == 0,
          "nacl: beforenm(alicepk, bobsk) != NaCl firstkey");
    CHECK(nacl_box_shared_get(k2, BOB_PK, ALICE_SK) == 0 && memcmp(k2, BOX_FIRSTKEY, 32) == 0,
          "nacl: shared_get (miss) != firstkey");
    CHECK(nacl_box_shared_get(k2, BOB_PK, ALICE_SK) == 0 && memcmp(k2, BOX_FIRSTKEY, 32) == 0,
          "nacl: shared_get (hit) != firstkey");

    for (size_t i = 0; i < sizeof(V) / sizeof(V[0]); i++) {
        size_t len = V[i].len;
        box_msg(m, len);

        memset(c, 0, sizeof(c));
        CHECK(nacl_box(c, m, len, BOX_NONCE, BOB_PK, ALICE_SK) == 0 &&
              memcmp(c, V[i].ct, len + 16) == 0, "nacl: box len %zu", len);
        memset(c, 0, sizeof(c));
        CHECK(nacl_box_afternm(c, m, len, BOX_NONCE, k) == 0 &&
              memcmp(c, V[i].ct, len + 16) == 0, "nacl: box_afternm len %zu", len);

        memset(p, 0xAA, sizeof(p));
        CHECK(nacl_box_open(p, V[i].ct, len + 16, BOX_NONCE, ALICE_PK, BOB_SK) == 0 &&
              memcmp(p, m, len) == 0, "nacl: box_open len %zu", len);
        memset(p, 0xAA, sizeof(p));
        CHECK(nacl_box_open_afternm(p, V[i].ct, len + 16, BOX_NONCE, k) == 0 &&
              memcmp(p, m, len) == 0, "nacl: box_open_afternm len %zu", len);

        for (size_t j = 0; j < len + 16; j += (len + 16) / 7 + 1) {
            memcpy(c, V[i].ct, len + 16);
            c[j] ^= 0x04;
            CHECK(nacl_box_open_afternm(p, c, len + 16, BOX_NONCE, k) != 0,
                  "nacl: len %zu flipped byte %zu accepted", len, j);
        }
    }
    CHECK(nacl_box_open_afternm(p, BOX_CT0, 15, BOX_NONCE, k) != 0, "nacl: short box accepted");
}

int main(void)
{
    test_x25519();
    test_chacha20poly1305();
    test_poly1305();
    test_blake2s();
    test_nacl_box();

    if (failures) {
        printf("%d crypto KAT failure(s)\n", failures);
        return 1;
    }
    printf("crypto KATs: all passed\n");
    return 0;
}
